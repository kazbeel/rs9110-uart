# IAR project RS9110_UART.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allahn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x2000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: AVR32
  ICCAVR32.CCIncludePath2: ..\..\include; ..\..\source
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  ICCAVR32.IccLang: 2
  AAVR32.ADefines: AVR32
  AAVR32.AIncludePaths: ..\..\include; ..\..\source
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCDefines: NDEBUG; AVR32
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  group include
    ../../include/: IPersistor.h RS9110_UART.h
  group source
    ../../source/: RS9110_UART.cpp
